# Keil uVision project sensor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: sensor
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT24C02.h I2C.h lcd.h PLAY.h playvideo.h Temp.h WAVE.h Global.h KeyTool.h
